# IAR project Project.ewp, settings and files
configuration IMXRT595-EVK-VGLite (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __MCUXPRESSO; __USE_CMSIS; NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; CUSTOM_VGLITE_MEMORY_CONFIG=0; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1; SDK_I2C_BASED_COMPONENT_USED=1; VG_BLIT_WORKAROUND=1; EW_USE_VGLITE_INDEX8=1; EW_USE_OPERATING_SYSTEM=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../Source; ..\..\..\ThirdParty\MCUXpressoSDK\CMSIS\Include; ..\..\..\ThirdParty\MCUXpressoSDK\CMSIS\Core\Include; ..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos_kernel\include; ..\..\..\ThirdParty\MCUXpressoSDK\rtos\freertos\freertos_kernel\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT595S; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT595S\drivers; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT595S\utilities; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT595S\utilities\debug_console; ..\..\..\ThirdParty\MCUXpressoSDK\devices\MIMXRT595S\utilities\str; ..\..\..\ThirdParty\MCUXpressoSDK\components\serial_manager; ..\..\..\ThirdParty\MCUXpressoSDK\components\uart; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dc; ..\..\..\ThirdParty\MCUXpressoSDK\components\video; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dc\lcdifv2; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dc\dsi_cmd; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\rm68200; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\mipi_dsi_cmd; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\rm68191; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\fbdev; ..\..\..\ThirdParty\MCUXpressoSDK\components\gt911; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dbi\flexio; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dbi; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dc\ssd1963; ..\..\..\ThirdParty\MCUXpressoSDK\components\ssd1963; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\dsi_cmd; ..\..\..\ThirdParty\MCUXpressoSDK\components\video\display\rm67162; ..\..\..\ThirdParty\MCUXpressoSDK\components\ektf2k; ..\..\..\ThirdParty\MCUXpressoSDK\components\ft3267; ..\..\..\ThirdParty\MCUXpressoSDK\middleware\vglite\inc; ..\..\..\ThirdParty\MCUXpressoSDK\middleware\vglite\VGLiteKernel; ..\..\..\ThirdParty\MCUXpressoSDK\middleware\vglite\VGLiteKernel\rtos; ..\..\..\ThirdParty\MCUXpressoSDK\middleware\vglite\VGLite\rtos; ..\..\..\PlatformPackage\RTE; ..\..\..\TargetSpecific; ..\..\..\TargetSpecific\Drivers; ..\..\GeneratedCode; ..\..\GeneratedCode\EmWiGfxInclude
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-IMXRT595-EVK-VGLite.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/: system_MIMXRT595S_cm33.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: board.c clock_config.c display_support.c flash_config.c pin_mux.c vglite_support.c
  group Drivers
    ../../../ThirdParty/MCUXpressoSDK/components/uart/: fsl_adapter_usart.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/: fsl_assert.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_flexcomm.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_mculcd.c fsl_flexio_mculcd_smartdma.c fsl_flexspi.c fsl_gpio.c fsl_i2c.c fsl_inputmux.c fsl_mipi_dsi.c fsl_mipi_dsi_smartdma.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_smartdma.c fsl_usart.c
    ../../../ThirdParty/MCUXpressoSDK/components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_port_uart.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/dc/ssd1963/: fsl_dc_fb_ssd1963.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/fbdev/: fsl_fbdev.c
    ../../../ThirdParty/MCUXpressoSDK/components/ft3267/: fsl_ft3267.c
    ../../../ThirdParty/MCUXpressoSDK/components/gt911/: fsl_gt911.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/rm67162/: fsl_rm67162.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/display/rm68200/: fsl_rm68200.c
    ../../../ThirdParty/MCUXpressoSDK/components/ssd1963/: fsl_ssd1963.c
    ../../../ThirdParty/MCUXpressoSDK/devices/MIMXRT595S/utilities/str/: fsl_str.c
    ../../../ThirdParty/MCUXpressoSDK/components/video/: fsl_video_common.c
  group Drivers/vglite
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLiteKernel/: vg_lite_kernel.c
    ../../../ThirdParty/MCUXpressoSDK/middleware/vglite/VGLite/rtos/: vg_lite_os.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: _ResourcesFontExtraLarge.h _ResourcesFontMedium.h _ResourcesFontSmall.h _ResourcesSymbolIconsLarge.h _WidgetSetCheckBoxMedium.h _WidgetSetHorizontalValueBarMedium.h _WidgetSetPushButtonMedium.h Application.c Core.c Effects.c Graphics.c Resources.c Views.c WidgetSet.c
    ../../../PlatformPackage/RGBA8888/: ewextbmp.h ewextfnt.h ewextgfx.h ewextpxl_RGBA8888.h ewgfx.h ewgfxcore.h ewgfxdefs.h ewgfxdriver.h ewgfxlinks.h ewgfxres.h ewgfxtasks.h
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: libewgfx-m33-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m33-iar.a
  group FreeRTOS
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/MCUXpressoSDK/rtos/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
